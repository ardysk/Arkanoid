# Keil uVision project BrickBreaker.uvprojx, settings and files
target FRDM-KL05Z (6160000::V6.16::ARMCLANG)
  device: MKL05Z32xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.1
  cpu: IRAM(0x1FFFFC00,0x00001000) IROM(0x00000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: BrickBreaker
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffffc00 size 0x1000
  group src
    ./: main.c gpio.c spi.c Fonts.c oled.c tsi.c arkanoid.c maps.c scores.c game.c game_draw.c menu.c keyboard.c
  group lib
    ./: gpio.h spi.h Fonts.h oled.h tsi.h frdm_bsp.h arkanoid.h maps.h scores.h game.h game_draw.h menu.h keyboard.h
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0
